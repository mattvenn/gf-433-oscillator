v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {vg decap ~3 pF: 6 x 30.71/4 um} 560 330 0 0 0.3 0.3 {}
T {as the v3 layout (gate on vg, S/D/B on VSS)} 560 355 0 0 0.3 0.3 {}
T {ring_core_v3: cfed ring + DAC + vg decap} -250 -560 0 0 0.6 0.6 {}
T {the LVS source of layout/ring_core_v3.gds} -250 -510 0 0 0.35 0.35 {}
T {vbn here = the DAC gate; vco_cfed drives it from the filtered vbnf} -250 -482 0 0 0.35 0.35 {}
C {devices/iopin.sym} -250 -300 0 0 {name=p28
lab=VDD}
C {devices/iopin.sym} -250 -270 0 0 {name=p29
lab=VSS}
C {devices/iopin.sym} -250 -240 0 0 {name=p30
lab=vbn}
C {devices/iopin.sym} -250 -210 0 0 {name=p31
lab=vctrl}
C {devices/iopin.sym} -250 -180 0 0 {name=p32
lab=bit0}
C {devices/iopin.sym} -250 -150 0 0 {name=p33
lab=bit1}
C {devices/iopin.sym} -250 -120 0 0 {name=p34
lab=bit2}
C {devices/iopin.sym} -250 -90 0 0 {name=p35
lab=bit3}
C {devices/iopin.sym} -250 -60 0 0 {name=p36
lab=bit4}
C {devices/iopin.sym} -250 -30 0 0 {name=p37
lab=bitb0}
C {devices/iopin.sym} -250 0 0 0 {name=p38
lab=bitb1}
C {devices/iopin.sym} -250 30 0 0 {name=p39
lab=bitb2}
C {devices/iopin.sym} -250 60 0 0 {name=p40
lab=bitb3}
C {devices/iopin.sym} -250 90 0 0 {name=p41
lab=bitb4}
C {devices/iopin.sym} -250 120 0 0 {name=p42
lab=vg}
C {devices/iopin.sym} -250 150 0 0 {name=p43
lab=a0}
C {devices/iopin.sym} -250 180 0 0 {name=p44
lab=a1}
C {devices/iopin.sym} -250 210 0 0 {name=p45
lab=a2}
C {devices/iopin.sym} -250 240 0 0 {name=p46
lab=a3}
C {devices/iopin.sym} -250 270 0 0 {name=p47
lab=a4}
C {cfed_ring.sym} 700 -60 0 0 {name=xring}
C {devices/lab_pin.sym} 600 -140 0 0 {name=p1
sig_type=std_logic
lab=VDD}
C {devices/lab_pin.sym} 600 -100 0 0 {name=p2
sig_type=std_logic
lab=vg}
C {devices/lab_pin.sym} 600 -60 0 0 {name=p3
sig_type=std_logic
lab=VSS}
C {devices/lab_pin.sym} 800 -140 0 1 {name=p4
sig_type=std_logic
lab=a0}
C {devices/lab_pin.sym} 800 -100 0 1 {name=p5
sig_type=std_logic
lab=a1}
C {devices/lab_pin.sym} 800 -60 0 1 {name=p6
sig_type=std_logic
lab=a2}
C {devices/lab_pin.sym} 800 -20 0 1 {name=p7
sig_type=std_logic
lab=a3}
C {devices/lab_pin.sym} 800 20 0 1 {name=p8
sig_type=std_logic
lab=a4}
C {cfed_dac.sym} 200 0 0 0 {name=xdac}
C {devices/lab_pin.sym} 90 -240 0 0 {name=p9
sig_type=std_logic
lab=vg}
C {devices/lab_pin.sym} 90 -200 0 0 {name=p10
sig_type=std_logic
lab=vbn}
C {devices/lab_pin.sym} 90 -160 0 0 {name=p11
sig_type=std_logic
lab=vctrl}
C {devices/lab_pin.sym} 310 -240 0 1 {name=p12
sig_type=std_logic
lab=VDD}
C {devices/lab_pin.sym} 310 -200 0 1 {name=p13
sig_type=std_logic
lab=VSS}
C {devices/lab_pin.sym} 90 -120 0 0 {name=p14
sig_type=std_logic
lab=bit0}
C {devices/lab_pin.sym} 90 -80 0 0 {name=p15
sig_type=std_logic
lab=bit1}
C {devices/lab_pin.sym} 90 -40 0 0 {name=p16
sig_type=std_logic
lab=bit2}
C {devices/lab_pin.sym} 90 0 0 0 {name=p17
sig_type=std_logic
lab=bit3}
C {devices/lab_pin.sym} 90 40 0 0 {name=p18
sig_type=std_logic
lab=bit4}
C {devices/lab_pin.sym} 90 80 0 0 {name=p19
sig_type=std_logic
lab=bitb0}
C {devices/lab_pin.sym} 90 120 0 0 {name=p20
sig_type=std_logic
lab=bitb1}
C {devices/lab_pin.sym} 90 160 0 0 {name=p21
sig_type=std_logic
lab=bitb2}
C {devices/lab_pin.sym} 90 200 0 0 {name=p22
sig_type=std_logic
lab=bitb3}
C {devices/lab_pin.sym} 90 240 0 0 {name=p23
sig_type=std_logic
lab=bitb4}
C {symbols/nfet_03v3.sym} 520 260 0 0 {name=DC
L=4.0u
W=30.71u
nf=1
m=6
ad=0
as=0
pd=0
ps=0
nrd=0
nrs=0
sa=0
sb=0
sd=0
model=nfet_03v3
spiceprefix=X}
C {devices/lab_pin.sym} 540 230 0 1 {name=p24
sig_type=std_logic
lab=VSS}
C {devices/lab_pin.sym} 500 260 0 0 {name=p25
sig_type=std_logic
lab=vg}
C {devices/lab_pin.sym} 540 290 0 1 {name=p26
sig_type=std_logic
lab=VSS}
C {devices/lab_pin.sym} 540 260 0 1 {name=p27
sig_type=std_logic
lab=VSS}
