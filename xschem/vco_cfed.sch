v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {vbnf: the filtered bias drives the DAC gates} -120 80 0 0 0.3 0.3 {}
T {vco_cfed: current-fed ring VCO, GF180MCU} -450 -560 0 0 0.6 0.6 {}
T {cgm_ref -> vbnf -> ring_core_v3 (ring + DAC + vg decap)} -450 -510 0 0 0.35 0.35 {}
T {code = bit[4:0] (coarse), vctrl (fine); out a0..a4} -450 -482 0 0 0.35 0.35 {}
T {source of truth: sim/vco/vco_bias.py netlist(), chosen design (xschem/gen/common.py)} -450 -454 0 0 0.35 0.35 {}
C {devices/iopin.sym} -450 -250 0 0 {name=p25
lab=VDD}
C {devices/iopin.sym} -450 -220 0 0 {name=p26
lab=VSS}
C {devices/iopin.sym} -450 -190 0 0 {name=p27
lab=vctrl}
C {devices/iopin.sym} -450 -160 0 0 {name=p28
lab=bit0}
C {devices/iopin.sym} -450 -130 0 0 {name=p29
lab=bit1}
C {devices/iopin.sym} -450 -100 0 0 {name=p30
lab=bit2}
C {devices/iopin.sym} -450 -70 0 0 {name=p31
lab=bit3}
C {devices/iopin.sym} -450 -40 0 0 {name=p32
lab=bit4}
C {devices/iopin.sym} -450 -10 0 0 {name=p33
lab=bitb0}
C {devices/iopin.sym} -450 20 0 0 {name=p34
lab=bitb1}
C {devices/iopin.sym} -450 50 0 0 {name=p35
lab=bitb2}
C {devices/iopin.sym} -450 80 0 0 {name=p36
lab=bitb3}
C {devices/iopin.sym} -450 110 0 0 {name=p37
lab=bitb4}
C {devices/iopin.sym} -450 140 0 0 {name=p38
lab=a0}
C {devices/iopin.sym} -450 170 0 0 {name=p39
lab=a1}
C {devices/iopin.sym} -450 200 0 0 {name=p40
lab=a2}
C {devices/iopin.sym} -450 230 0 0 {name=p41
lab=a3}
C {devices/iopin.sym} -450 260 0 0 {name=p42
lab=a4}
C {devices/iopin.sym} -450 290 0 0 {name=p43
lab=vg}
C {devices/iopin.sym} -450 320 0 0 {name=p44
lab=vbn}
C {devices/iopin.sym} -450 350 0 0 {name=p45
lab=vbnf}
C {cgm_ref.sym} 0 0 0 0 {name=xref}
C {devices/lab_pin.sym} -100 -20 0 0 {name=p1
sig_type=std_logic
lab=VDD}
C {devices/lab_pin.sym} -100 20 0 0 {name=p2
sig_type=std_logic
lab=VSS}
C {devices/lab_pin.sym} 100 -20 0 1 {name=p3
sig_type=std_logic
lab=vbn}
C {devices/lab_pin.sym} 100 20 0 1 {name=p4
sig_type=std_logic
lab=vbnf}
C {ring_core_v3.sym} 500 0 0 0 {name=xcore}
C {devices/lab_pin.sym} 380 -260 0 0 {name=p5
sig_type=std_logic
lab=VDD}
C {devices/lab_pin.sym} 380 -220 0 0 {name=p6
sig_type=std_logic
lab=VSS}
C {devices/lab_pin.sym} 380 -180 0 0 {name=p7
sig_type=std_logic
lab=vbnf}
C {devices/lab_pin.sym} 380 -140 0 0 {name=p8
sig_type=std_logic
lab=vctrl}
C {devices/lab_pin.sym} 620 -260 0 1 {name=p9
sig_type=std_logic
lab=vg}
C {devices/lab_pin.sym} 380 -100 0 0 {name=p10
sig_type=std_logic
lab=bit0}
C {devices/lab_pin.sym} 380 -60 0 0 {name=p11
sig_type=std_logic
lab=bit1}
C {devices/lab_pin.sym} 380 -20 0 0 {name=p12
sig_type=std_logic
lab=bit2}
C {devices/lab_pin.sym} 380 20 0 0 {name=p13
sig_type=std_logic
lab=bit3}
C {devices/lab_pin.sym} 380 60 0 0 {name=p14
sig_type=std_logic
lab=bit4}
C {devices/lab_pin.sym} 380 100 0 0 {name=p15
sig_type=std_logic
lab=bitb0}
C {devices/lab_pin.sym} 380 140 0 0 {name=p16
sig_type=std_logic
lab=bitb1}
C {devices/lab_pin.sym} 380 180 0 0 {name=p17
sig_type=std_logic
lab=bitb2}
C {devices/lab_pin.sym} 380 220 0 0 {name=p18
sig_type=std_logic
lab=bitb3}
C {devices/lab_pin.sym} 380 260 0 0 {name=p19
sig_type=std_logic
lab=bitb4}
C {devices/lab_pin.sym} 620 -220 0 1 {name=p20
sig_type=std_logic
lab=a0}
C {devices/lab_pin.sym} 620 -180 0 1 {name=p21
sig_type=std_logic
lab=a1}
C {devices/lab_pin.sym} 620 -140 0 1 {name=p22
sig_type=std_logic
lab=a2}
C {devices/lab_pin.sym} 620 -100 0 1 {name=p23
sig_type=std_logic
lab=a3}
C {devices/lab_pin.sym} 620 -60 0 1 {name=p24
sig_type=std_logic
lab=a4}
